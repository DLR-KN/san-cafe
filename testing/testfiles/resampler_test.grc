<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resampler_taps</value></param>
<param><key>value</key><value> [-1.9683642449308536e-07, 1.4681120319437468e-07, 7.663523433620867e-07, 1.4213405847840477e-06, 1.1561321571207372e-06, -9.483845815339009e-07, -4.443665147846332e-06, -6.849767942185281e-06, -4.7888725021039136e-06, 3.2090906643134076e-06, 1.4037330402061343e-05, 2.006744034588337e-05, 1.3317001503310166e-05, -7.862377060519066e-06, -3.409927012398839e-05, -4.722411904367618e-05, -3.0732113373233005e-05, 1.6364505427191034e-05, 7.194292265921831e-05, 9.80462136794813e-05, 6.333821511361748e-05, -3.0663264624308795e-05, -0.00013817792932968587, -0.0001866567909019068, -0.00012038779095746577, 5.312982830218971e-05, 0.0002472712949384004, 0.0003324616118334234, 0.00021479032875504345, -8.64363246364519e-05, -0.00041809427784755826, -0.0005610609659925103, -0.00036387890577316284, 0.00013336981646716595, 0.0006744240527041256, 0.0009051666711457074, 0.0005902263219468296, -0.00019658256496768445, -0.0010454192524775863, -0.001405553426593542, -0.0009225395042449236, 0.0002782895171549171, 0.0015661459183320403, 0.002112175105139613, 0.0013967403210699558, -0.00037993595469743013, -0.002278354251757264, -0.0030857662204653025, -0.0020574727095663548, 0.0005018720985390246, 0.0032319151796400547, 0.004400545731186867, 0.0029605275485664606, -0.0006430748617276549, -0.0044876509346067905, -0.006149217486381531, -0.00417714798822999, 0.0008009591256268322, 0.00612297561019659, 0.008452558889985085, 0.005802100989967585, -0.000971318397205323, -0.008243095129728317, -0.011478251777589321, -0.00796947255730629, 0.001148419687524438, 0.011003663763403893, 0.015479139983654022, 0.010885084047913551, -0.0013252622447907925, -0.014658775180578232, -0.020875684916973114, -0.014897762797772884, 0.0014939912362024188, 0.01967124082148075, 0.028450964018702507, 0.020673425868153572, -0.0016464353539049625, -0.027000663802027702, -0.03988238051533699, -0.029692694544792175, 0.0017747196834534407, 0.03902057930827141, 0.05955108255147934, 0.04607751965522766, -0.0018718952778726816, -0.06357859820127487, -0.10358824580907822, -0.08718627691268921, 0.0019325199536979198, 0.15052901208400726, 0.31746333837509155, 0.4484784007072449, 0.4980469346046448, 0.4484784007072449, 0.31746333837509155, 0.15052901208400726, 0.0019325199536979198, -0.08718627691268921, -0.10358824580907822, -0.06357859820127487, -0.0018718952778726816, 0.04607752338051796, 0.05955108255147934, 0.03902057930827141, 0.0017747196834534407, -0.029692696407437325, -0.03988238051533699, -0.02700066566467285, -0.0016464354703202844, 0.02067342773079872, 0.028450964018702507, 0.0196712426841259, 0.0014939912362024188, -0.014897762797772884, -0.020875684916973114, -0.014658776111900806, -0.0013252620119601488, 0.010885081253945827, 0.015479137189686298, 0.011003661900758743, 0.0011484193382784724, -0.00796947255730629, -0.011478248983621597, -0.008243093267083168, -0.0009713182807900012, 0.005802099592983723, 0.008452557027339935, 0.0061229742132127285, 0.0008009588345885277, -0.004177146591246128, -0.006149216089397669, -0.004487650003284216, -0.0006430746288970113, 0.0029605263844132423, 0.004400544334203005, 0.0032319133169949055, 0.0005018719239160419, -0.002057471079751849, -0.0030857673846185207, -0.0022783551830798388, -0.0003799361293204129, 0.0013967410195618868, 0.0021121760364621878, 0.0015661466168239713, 0.00027828963357023895, -0.0009225401445291936, -0.001405554125085473, -0.0010454198345541954, -0.00019658268138300627, 0.000590226729400456, 0.0009051673114299774, 0.0006744241109117866, 0.00013336986012291163, -0.0003638789930846542, -0.0005610610824078321, -0.00041809436515904963, -8.643634646432474e-05, 0.0002147902559954673, 0.00033246143721044064, 0.00024727138224989176, 5.3129857406020164e-05, -0.000120387805509381, -0.0001866566890385002, -0.0001381779002258554, -3.066325734835118e-05, 6.333823694149032e-05, 9.804654109757394e-05, 7.194287900347263e-05, 1.6364474504371174e-05, -3.073202969972044e-05, -4.7224304580595344e-05, -3.409937198739499e-05, -7.862387974455487e-06, 1.3317104276211467e-05, 2.0067382138222456e-05, 1.4037326764082536e-05, 3.2090420063468628e-06, -4.788931619259529e-06, -6.849907549622003e-06, -4.443440047907643e-06, -9.483809435550938e-07, 1.156079974862223e-06, 1.4214483599062078e-06, 7.663352903364284e-07, 1.4675376291961584e-07, -1.9683642449308536e-07]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>512e3</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>3</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1024-186</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>resampler_test_in.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>resampler_test_out.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/jkraemer/Dev/san-cafe/testing/testfiles/resampler_test_in.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>1024</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_psk_mod</key>
<param><key>id</key><value>digital_psk_mod_0</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>excess_bw</key><value>0.2</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>4</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>30</value></param>
<param><key>rrate</key><value>15.0/16</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>resampler_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>digital_psk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_mod_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_mod_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
